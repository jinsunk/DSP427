# IAR project dsp427.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427II ST STM32F427II
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F427X; USE_STDPERIPH_DRIVER; HSE_VALUE=25000000L; NDEBUG
  ICCARM.CCIncludePath2: Target\inc; Libraries\CMSIS\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; \Libraries\CMSIS\Device\ST\STM32F4xx\Include; Common\inc; Drivers\inc; User\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dsp427.bin
  ILINK.IlinkOutputFile: dsp427.out
  ILINK.IlinkIcfFile: Target\stm32f427xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    Target/: stm32f427xI.icf
  group Common
    Common/src/: list.c main.c procmsg.c routine.c sysmsg.c timer.c
  group StdPeriph
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f427x.s
    Target/src/: system_stm32f4xx.c
  group Target
    Target/src/: board_dsp427.c syscntl.c
  group User
    User/src/: console.c
